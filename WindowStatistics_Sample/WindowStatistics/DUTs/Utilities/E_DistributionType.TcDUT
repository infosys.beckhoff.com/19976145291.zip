{attribute 'qualified_only'}
TYPE E_DistributionType :
(
	Uniform := 0,
	Normal,
	Chi_squared,
	Exponential,
	Gamma
);
END_TYPE
