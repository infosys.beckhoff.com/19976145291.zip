TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_Spectrum,
	eID_Statistics,
	eID_SinkSpectrum,
	eID_SinkStatistics
) UDINT;
END_TYPE
